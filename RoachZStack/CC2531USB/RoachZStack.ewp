# IAR project RoachZStack.ewp, settings and files
configuration CoordinatorUSB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2531F256.i51
  ICC8051.CCDefines: HAL_UART=TRUE; HAL_DMA=TRUE; SERIAL_APP_PORT=0
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\..\ZMain\TI2530DB; $_ZSTACK_$\hal\include; $_ZSTACK_$\hal\target\CC2530USB; $_ZSTACK_$\hal\target\CC2530USB\usb\library; $_ZSTACK_$\hal\target\CC2530USB\usb\library\cc2531; $_ZSTACK_$\hal\target\CC2530USB\usb\class_cdc; $_ZSTACK_$\mac\include; $_ZSTACK_$\mac\high_level; $_ZSTACK_$\mac\low_level\srf04; $_ZSTACK_$\mac\low_level\srf04\single_chip; $_ZSTACK_$\mt; $_ZSTACK_$\osal\include; $_ZSTACK_$\services\saddr; $_ZSTACK_$\services\sdata; $_ZSTACK_$\stack\af; $_ZSTACK_$\stack\nwk; $_ZSTACK_$\stack\sapi; $_ZSTACK_$\stack\sec; $_ZSTACK_$\stack\sys; $_ZSTACK_$\stack\zdo; $_ZSTACK_$\zmac; $_ZSTACK_$\zmac\f8w
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\Tools\CC2530DB\f8w2530.xcl
configuration RouterUSB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: HAL_UART=TRUE; SERIAL_APP_PORT=0; ZIGBEE_FRAGMENTATION
  ICC8051.CCOptLevel: 1
configuration EndDeviceUSB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; xPOWER_SAVING; HAL_DMA=TRUE
  ICC8051.CCOptLevel: 3
  group App
    ../Source/: commands.c commands.h OSAL_RoachZStack.c RoachZStack.c RoachZStack.h RoachZStack_ADC.c RoachZStack_ADC.h RoachZStack_Endpoint.c ZConfig.h
  group HAL/Common
    $_ZSTACK_$/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    $_ZSTACK_$/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2530USB/Config
    $_ZSTACK_$/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2530USB/Drivers
    $_ZSTACK_$/hal/target/CC2530USB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530USB/Includes
    $_ZSTACK_$/hal/target/CC2530USB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2530USB/USB/class_cdc
    $_ZSTACK_$/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2530USB/USB/library
    $_ZSTACK_$/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2530USB/USB/library/cc2531
    $_ZSTACK_$/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    $_ZSTACK_$/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    $_ZSTACK_$/mac/include/: mac_api.h
  group MAC/Low Level/Common
    $_ZSTACK_$/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    $_ZSTACK_$/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    $_ZSTACK_$/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    $_ZSTACK_$/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    $_ZSTACK_$/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    $_ZSTACK_$/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    $_ZSTACK_$/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    $_ZSTACK_$/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    $_ZSTACK_$/stack/af/: AF.c AF.h
  group Security
    $_ZSTACK_$/stack/sec/: ssp.h ssp_hash.h
  group Services
    $_ZSTACK_$/services/saddr/: saddr.c saddr.h
  group Tools
    ../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    $_ZSTACK_$/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    $_ZSTACK_$/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    $_ZSTACK_$/zmac/: ZMAC.h
  group ZMain
    ../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
