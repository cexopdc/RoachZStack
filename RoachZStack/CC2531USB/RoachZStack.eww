<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RoachZStack.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>RoachZStack</project>
        <configuration>CoordinatorUSB</configuration>
      </member>
      <member>
        <project>RoachZStack</project>
        <configuration>RouterUSB</configuration>
      </member>
      <member>
        <project>RoachZStack</project>
        <configuration>EndDeviceUSB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


